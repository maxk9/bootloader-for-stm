<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Bootloader\PC_Bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Appl\PulseCounter.ewp</path>
  </project>
  <batchBuild/>
</workspace>


