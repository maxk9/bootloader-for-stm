# IAR project Backup of PC_Bootloader.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; inc; STM8L15x_StdPeriph_Driver/inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: PC_Bootloader.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkIcfFile: lnkstm8l152c6_led.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Drivers
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_tim1.c
  group User
    Src/: cp_comm.c
    ./: main.c stm8l15x_it.c
