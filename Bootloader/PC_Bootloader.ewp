# IAR project PC_Bootloader.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: PC_Bootloader.bin
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkIcfFile: D:\FDSI\PulseCounter\Bootloader\lnkstm8l151g6.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Drivers
    src/: stm8l15x_clk.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_iwdg.c
  group Include files
    ./: main.h
  group User
    ./: main.c stm8l15x_conf.h stm8l15x_interrupt.s
