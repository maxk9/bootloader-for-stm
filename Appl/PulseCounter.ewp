# IAR project PulseCounter.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_FULL_ASSERT
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; inc; STM8L15x_StdPeriph_Driver/inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: FPC_mcu.bin
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkIcfFile: D:\FDSI\PulseCounter\Appl\lnkstm8l152c6_led.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  OBJCOPY.OOCOutputFile: PulseCounter.hex
  ILINK.IlinkOutputFile: PulseCounter.out
  ILINK.IlinkIcfFile: lnkstm8l152c6_led.icf
  group Drivers
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_iwdg.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c
  group User
    src/: box_open.c cp_comm.c led.c
    ./: lnkstm8l152c6_led.icf main.c stm8l15x_it.c
